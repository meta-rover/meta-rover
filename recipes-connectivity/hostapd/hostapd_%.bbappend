do_install_append() {
	# Set our default wifi config
}
