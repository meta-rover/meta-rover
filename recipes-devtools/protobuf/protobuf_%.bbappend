
CXXFLAGS += " -shared"

LDFLAGS_append = " -lz"
